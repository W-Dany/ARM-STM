# Keil uVision project demo.uvprojx, settings and files
target demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\HALLIB\Inc;..\CMSIS;..\USER;..\INCLUDE;..\BSP;..\BSP\led;..\BSP\sys;..\BSP\delay;..\uCOS-III\uC-CPU;..\uCOS-III\uC-CPU\ARM-Cortex-M4;..\uCOS-III\uC-LIB;..\uCOS-III\uCOS-III\Source;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4;..\uCOS-III
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../STARTUP/: startup_stm32f429xx.s
  group cmsis
    ../CMSIS/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group hallib
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c
  group user
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group bsp
    ../BSP/led/: led.c
    ../BSP/sys/: sys.c
    ../BSP/delay/: delay.c
    ../BSP/: bsp.c
  group ucos/cpu
    ../uCOS-III/uC-CPU/: cpu_core.c
    ../uCOS-III/uC-CPU/ARM-Cortex-M4/: cpu_c.c cpu_a.asm
  group ucos/lib
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/: lib_mem_a.asm
  group ucos/src
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos/port
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/: os_cpu_a.asm os_cpu_c.c
